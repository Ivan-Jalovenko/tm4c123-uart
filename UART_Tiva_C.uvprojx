# Keil uVision project UART_Tiva_C.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_Tiva_C
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src;.\HAL\LED;.\HAL\UART;.\UI
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: config.h constants.h main.c
  group UART
    ./HAL/UART/: UART.c UART.h
  group UI
    ./HAL/UI/: UI.c UI.h
  group LED
    ./HAL/LED/: LED.c LED.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
